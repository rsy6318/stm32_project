# Keil uVision project TIMER.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TIMER
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Inc/: stm32f4xx_it.h
software components: CMSIS:CORE 4.1.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:TIM 1.5.0, Device:Startup 2.5.0
